require ${BPN}.inc

SRCREV = "6ef7c55176a8487ae7ca53c2e0649d5df9a1b3b4"

