require ${BPN}.inc

SRCREV = "e7d6c6af38a1a7b8b300c346037c83fa31dc5d2c"

