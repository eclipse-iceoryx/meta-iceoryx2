require ${BPN}.inc

SRCREV = "9b4dedb0deeba7218266502008c9b654a1d9ea71"
