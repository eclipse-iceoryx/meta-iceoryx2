require ${BPN}.inc

SRCREV = "2e64dd8c18d7abe2065760d3d31addfedcd17161"

