require ${BPN}.inc

SRCREV = "e4ecf58d2d5e600af8d841bb448166addfbb9838"
