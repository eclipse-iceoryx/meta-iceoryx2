require ${BPN}.inc

SRCREV = "d49aebe9f963edf01474925819466d1eee0a1193"

