require ${BPN}.inc

SRCREV = "b4042aa2aafe5f0d613a263e7cd4bbf8afb4a34e"
