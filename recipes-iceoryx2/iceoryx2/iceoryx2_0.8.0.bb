require ${BPN}.inc

SRCREV = "1979e6edf2316ebe7b30751c7172972ed3452c5b"
CARGO_FEATURES = "iceoryx2/libc_platform"
