require ${BPN}.inc

SRCREV = "adf3f519755072e1f62e6a3396cbf4cc7e514e47"
CARGO_FEATURES = "iceoryx2/libc_platform"
